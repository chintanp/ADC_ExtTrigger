# Keil uVision project ADC_ExternalTrigger.uvproj, settings and files
target ADC_ExternalTrigger (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: ADC_ExternalTrigger
  c flags: Optim=1 OneElfS=1
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: startup.s ADC_ExternalTrigger.c ADC_MainUART.c PLL.c UART.c
